# Keil uVision project Tracking_Device.uvprojx, settings and files
target Tracking_Device (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L073RZ STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: Tracking_Device
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L073xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;..\Services\ADC\inc;..\Services\Global_Includes;..\Services\GPRS_Service\inc;..\Services\GPS_Service\inc;..\Services\GSM_Service\inc;..\Services\Helpers\inc;..\Services\I2C_Service\inc;..\Services\Logging_Service\inc;..\Services\Power_Down_GPIO_Service\inc;..\Services\TimerService\inc;..\Services\UART_Service\inc;..\Services\Watchdog_Service\inc;..\FATFS\inc;..\Services\FatFS_Service\inc;..\Services\HB_Service\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_tim.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_lptim.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_spi.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_flash.c stm32l0xx_hal_adc.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_dma.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_cortex.c stm32l0xx_hal_rcc_ex.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Application/MDK-ARM
    ./: startup_stm32l073xx.s
  group Application/User
    ../Src/: main.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Services
    ../Services/ADC/src/: ADC_Service.c
    ../Services/GPRS_Service/src/: GPRS.c
    ../Services/GPS_Service/src/: GPS.c
    ../Services/GSM_Service/src/: GSM.c
    ../Services/I2C_Service/src/: I2C_service.c
    ../Services/Logging_Service/src/: logging_service.c
    ../Services/Power_Down_GPIO_Service/src/: Power_Down.c
    ../Services/TimerService/src/: TimerService.c
    ../Services/Watchdog_Service/src/: Watchdog_Service.c
    ../Services/UART_Service/src/: UART_Service.c
    ../Services/FatFS_Service/src/: FATFS_Service.c
    ../Services/HB_Service/src/: HB_Service.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c ff_2_SPI_Link.c
software components: CMSIS:CORE 4.1.0
